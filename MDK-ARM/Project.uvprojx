# Keil uVision project Project.uvprojx, settings and files
target Y6 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: TDOGUIV1_0 +hex
  AfterMake: fromelf --bin ".\Obj\@L.axf" --output ".\Obj\@L.bin"
  AfterMake: fromelf --text -c ".\Obj\@L.axf" --output ".\Obj\@L.txt"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: D:\Keil_v5\ARM\ARMCC\include;..\inc;.\TDO_Y6xxBSP\CMSIS\Device\TDO\Y6\Include;.\TDO_Y6xxBSP\Y6_StdPeriph_Driver\inc;.\Driver;.\myY6GUI\Interface;.\gHMIY6GUI;.\gHMIY6GUI\includes\UsersProvided;.\gHMIY6GUI\includes\UsersUse;.\APP_CODE;.\TDO_Driver;.\APP_CODE\usr
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8f0
  scatter file: .\Obj\Y6_Xip.sct
  group CMSIS
    ../src/: main.c Y6_it.c Y6_init.c
    ./TDO_Y6xxBSP/CMSIS/Device/TDO/Y6/Source/Templates/: system_Y6.c
    ./TDO_Y6xxBSP/CMSIS/Device/TDO/Y6/Source/Templates/arm/: startup_Y6.s
  group BSP
    ./TDO_Y6xxBSP/Y6_StdPeriph_Driver/src/: Y6_dma.c Y6_gpio.c Y6_i2c.c Y6_qspi.c Y6_rcc.c Y6_tim.c Y6_usart.c misc.c Y6_eval_qspi.c
  group Driver
    ./Driver/: lcdDriver.c lcdInit.c Y6_utility_i2c.c Y6_xip_write.c SystemHeart.c SystemUart.c QspiDMA.c lcdInterface.c memoryInterface.c flashInterface.c rtcDriver.c comInterface.c lcdWrite.s Key.c MMC_SD.C
    ./TDO_Y6xxBSP/Y6_StdPeriph_Driver/src/: Y6_adc.c
  group OBJ
    ./Obj/: encryption.o lcd_spi_init.o y6_otp.o decrypt.o
  group Y6GUI/lib
    ./gHMIY6GUI/: Y6GUI.lib
  group Y6GUI/Includes
    ./gHMIY6GUI/includes/UsersProvided/: flashInterface.h lcdInterface.h memoryInterface.h comInterface.h
    ./gHMIY6GUI/includes/UsersUse/: gReturn.h gStdint.h gResMsg.h guiConfig.c guiConfig.h guiFunc.h gWidgetInfo.h
  group TDO_Driver
    ./TDO_Driver/: PWM.c Led.c Y6_command.c Y6_comParacommand.c Y6_drawFigure.c Y6_drawchar.c Y6_SystemFontLib.c
  group APP_CODE
    ./APP_CODE/usr/: DemoTest01.c Encoder.c
software components: CMSIS:CORE 5.5.0
